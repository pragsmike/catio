options:
  parameters:
    author: mg
    generate_options: qt_gui
    id: pulseview
    output_language: python
    title: Pulse Viewer
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '94000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: file8_0_1.25756383.dat
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
