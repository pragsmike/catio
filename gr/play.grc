options:
  parameters:
    author: mg
    generate_options: qt_gui
    id: play
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '22500'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '22500'
    max_dev: 5e3
    quad_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/mg/Documents/signals/file10_12_3.49170250.dat
    repeat: 'True'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_nbfm_rx_0, '0', audio_sink_0, '0']
- [blocks_file_source_0, '0', analog_nbfm_rx_0, '0']
- [blocks_file_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
