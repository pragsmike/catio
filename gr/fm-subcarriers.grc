options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: audio_decim
  id: variable
  parameters:
    value: '5'
  states: {}
- name: audio_decim_rate
  id: variable
  parameters:
    value: baseband_rate/audio_decim
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: baseband_rate
  id: variable
  parameters:
    value: samp_rate/bb_decim
  states: {}
- name: bb_decim
  id: variable
  parameters:
    value: '4'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: freq
    orient: Qt.Horizontal
    start: 88.5e6
    step: 200e3
    stop: 108e6
    value: 90.9e6
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: freq_tune
  id: variable
  parameters:
    value: freq - freq_offset
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    label: gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '75'
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: xlate_bandwidth
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '15000'
    audio_stop: '16000'
    chan_rate: audio_decim_rate
    deviation: '5000'
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: bb_decim
    quad_rate: samp_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_rate
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    decim: audio_decim
    taps: firdes.low_pass(1.0,baseband_rate,13e3,3e3,firdes.WIN_HAMMING)
    type: fff
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_offset
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, xlate_bandwidth, 100000)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 67e3
    decim: audio_decim
    samp_rate: baseband_rate
    taps: firdes.low_pass(2500.0,baseband_rate,3e3,2e3,firdes.WIN_HAMMING)
    type: fcc
  states: {}
- name: nb
  id: qtgui_tab_widget
  parameters:
    label0: Baseband
    label1: Demod
    label2: L+R
    label3: Subcarrier
    num_tabs: '4'
  states: {}
- name: note_0
  id: note
  parameters:
    note: L+R
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    dc_offset_mode0: '2'
    freq0: freq_tune
    gain0: gain
    gain_mode0: 'True'
    if_gain0: '20'
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: baseband_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: nb@1
    showports: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: nb@2
    showports: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: nb@0
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: nb@1
    label1: Demod
    showports: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_1_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: baseband_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: nb@3
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: freq_tune
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [analog_fm_demod_cf_0, '0', audio_sink_0, '0']
- [analog_wfm_rcv_0, '0', fir_filter_xxx_1, '0']
- [analog_wfm_rcv_0, '0', freq_xlating_fir_filter_xxx_1, '0']
- [analog_wfm_rcv_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_waterfall_sink_x_1, '0']
- [fir_filter_xxx_1, '0', audio_sink_0_0, '0']
- [fir_filter_xxx_1, '0', qtgui_freq_sink_x_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_wfm_rcv_0, '0']
- [freq_xlating_fir_filter_xxx_1, '0', analog_fm_demod_cf_0, '0']
- [freq_xlating_fir_filter_xxx_1, '0', qtgui_waterfall_sink_x_1_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
